*|||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||
*|||| FINAL PROJECT IE3043 by Carlos Esquit           								                      ||||||||
*|||| Universidad Del Valle de Guatemala                                                                  ||||||||
*|||| Serial Multiplier (24 bits)                                                                         ||||||||
*|||| May 2020                                              											  ||||||||
*|||| (Ricardo Girón          /16556)                         											  ||||||||
*|||| (Charlie Cruz           /16157)                         											  ||||||||
*|||| (Matthias Sibrián       /16247)                          											  ||||||||
*|||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||

*********************************************** INCLUDE ****************************************************************************************
.include 'sub.sp'
.include 'sources.sp'
.include 'params.sp'
.include '32nm.sp'
.include 'Analysis.sp'
.include 'subct_adder12bits.sp'
************************************************************************************************************************************************
*X2 A 0 CLOCK out Vdd MUX size=1

*********************************************** CMOS POSITIVE EDGE TRIGGERED D FLIP-FLOP *******************************************************
*X1 D CLOCK Q Vdd DFF size=1
************************************************************************************************************************************************

******************************************************ADDER 12 bits *****************************************************************************
X4  Q24 Q23 Q22 Q21 Q20 Q19 Q18 Q17 Q16 Q15 Q14 Q13     0 0 Vdd Vdd Vdd 0 0 0 0 Vdd Vdd Vdd    0 k12  s11 s10 s09 s08 s07 s06 s05 s04 s03 s02 s01 s00 Vdd Sum12 size = 1
*************************************************************************************************************************************************

*             D1 D2  D3 D4 D5 D6 D7 D8 D9 D10 D11 D12 D13
******************************************************SHIFT REGISTER ****************************************************************************
X3 Q24 CLOCK Vdd Vdd 0 Vdd 0 Vdd Vdd 0 Vdd 0 Vdd 0 Vdd 0 Vdd 0 0 0 0 0 0 0 0 0 Q1 Q2 Q3 Q4 Q5 Q6 Q7 Q8 Q9 Q10 Q11 Q12 Q13 Q14 Q15 Q16 Q17 Q18 Q19 Q20 Q21 Q22 Q23 Q24 Vdd SRP size=1
*************************************************************************************************************************************************

*Se hace la carga paralela y sus condiciones iniciales
.IC V(Q1) = 0
.IC V(Q2) = 0
.IC V(Q3) = 0
.IC V(Q4) = 0
.IC V(Q5) = 0
.IC V(Q6) = 0
.IC V(Q7) = 0
.IC V(Q8) = 0
.IC V(Q9) = 0
.IC V(Q10) = 0
.IC V(Q11) = 0
.IC V(Q12) = 0
.IC V(Q13) = 0

*El multiplicador va a partir de aqui
.IC V(Q14) = 0
.IC V(Q15) = Vdd1
.IC V(Q16) = 0
.IC V(Q17) = Vdd1
.IC V(Q18) = 0
.IC V(Q19) = Vdd1
.IC V(Q20) = 0
.IC V(Q21) = Vdd1
.IC V(Q22) = 0
.IC V(Q23) = Vdd1
.IC V(Q24) = 0
.IC V(D)=0
.IC V(CLOCK)=0

**.TRAN 100p 9n**
.option post

.END
