*|||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||
*|||| FINAL PROJECT IE3043 by Carlos Esquit           								                      ||||||||
*|||| Universidad Del Valle de Guatemala                                                                  ||||||||
*|||| Serial Multiplier (24 bits)                                                                         ||||||||
*|||| May 2020                                              											  ||||||||
*|||| (Ricardo Girón          /16556)                         											  ||||||||
*|||| (Charlie Cruz           /16157)                         											  ||||||||
*|||| (Matthias Sibrián       /16247)                          											  ||||||||
*|||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||||

*********************************************** INCLUDE ****************************************************************************************
.include 'sub.sp'
.include 'sources.sp'
.include 'params.sp'
.include '32nm.sp'
.include 'Analysis.sp'
************************************************************************************************************************************************
*X2 A 0 CLOCK out Vdd MUX size=1

*********************************************** CMOS POSITIVE EDGE TRIGGERED D FLIP-FLOP *******************************************************
*X1 D CLOCK Q Vdd DFF size=1
************************************************************************************************************************************************

******************************************************SHIFT REGISTER ****************************************************************************
X3 SCTRL CLOCK Vdd Vdd 0 Vdd 0 Vdd Vdd 0 Vdd 0 Vdd Vdd 0 Vdd 0 Vdd Vdd 0 Vdd 0 Vdd Vdd 0 Vdd Q1 Q2 Q3 Q4 Q5 Q6 Q7 Q8 Q9 Q10 Q11 Q12 Q13 Q14 Q15 Q16 Q17 Q18 Q19 Q20 Q21 Q22 Q23 Q24 Vdd SRP size=1
*************************************************************************************************************************************************

.IC V(D)=0
.IC V(CLOCK)=0

**.TRAN 100p 7n**
.option post

.END
